# Keil uVision project dll_generate.uvprojx, settings and files
target DLL_Generate (6160000::V6.16::ARMCLANG)
  device: ARMCM7_DP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ESEL ELITTLE
  output: dll_generate
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -nostdlib
  c include: ..\common
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\dll_generate.sct
  link misc: --base_platform --entry=dl_main --export_dynamic  --no_comment_section --no_debug
  group USER
    ./: dl_main.c
  group EXTERN_LIB
    ./app/: dl_stdio_lib.c dl_stdlib_lib.c dl_string_lib.c dl_time_lib.c
